# Keil uVision project Project.uvprojx, settings and files
target standalone (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F769NIHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: Project
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F769xx,USE_HAL_DRIVER,USE_STM32F769I_DISCO,DATA_IN_ExtSDRAM,USE_LCD_HDMI,USE_USB_HS,STM32_SDK,BSP_DRIVER
  c include: ..\Inc;..\common\STM32F7xx_Driver\Inc;..\common\FatFs\src;..\common\STM32F7xx_Driver\BSP\Components\Common;..\common\STM32F7xx_Driver\BSP\STM32F769I-Discovery;..\common\STM32F7xx_Driver\CMSIS\Device\ST\STM32F7xx\Include;..\doom\src;..\doom\src\chocdoom;..\common\inc;..\hexen
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  scatter file: .\standalone.sct
  group hal
    ../common/STM32F7xx_Driver/Src/: stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal.c stm32f7xx_hal_rcc.c stm32f7xx_hal_gpio.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_pwr.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_jpeg.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_ll_fmc.c stm32f7xx_hal_dsi.c stm32f7xx_hal_dfsdm.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_i2s.c stm32f7xx_ll_spi.c stm32f7xx_hal_spi.c stm32f7xx_hal_qspi.c stm32f7xx_hal_hcd.c stm32f7xx_ll_usb.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c
  group cmsis
    ../Src/: system_stm32f7xx.c
  group startup
    ./: startup_stm32f769xx.s
  group main
    ../Src/: main.c
    ../doom/src/: i_sdlsound.c
    ../common/: mach_stub.c bsp_api.c heap.c dev_main.c
    ../common/misc/arch/Arm/m7/src/: machM7.s asm_utils.s
    ../common/lib/: dstring.c
  group fatfs
    ../common/FatFs/src/option/: unicode.c syscall.c
    ../common/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group usbh
    ../common/: usbh_conf.c usbh_core.c usbh_ctlreq.c usbh_hid.c usbh_hid_keybd.c usbh_hid_mouse.c usbh_hid_parser.c usbh_ioreq.c usbh_pipes.c
  group common
    ../common/: mpu.c lcd_main.c input_main.c usb_hid_gamepad.c audio_main.c audio_ext.c audio_mem.c audio_mix.c music_main.c sd_diskio.c serial.c dev_io.c nvic.c hdmi_mem.c bsp_cmd.c dev_cmd.c dev_io_pub.c profiler.c qspi_flash.c retarget.c term.c tim.c
  group hexen
    ../hexen/: a_action.c am_map.c ct_chat.c d_net.c f_finale.c g_game.c h2_main.c in_lude.c info.c m_random.c mn_menu.c p_acs.c p_anim.c p_ceilng.c p_doors.c p_enemy.c p_floor.c p_inter.c p_lights.c p_map.c p_maputl.c p_mobj.c p_plats.c p_pspr.c p_setup.c p_sight.c p_spec.c p_switch.c p_telept.c p_things.c p_tick.c p_user.c po_man.c r_bsp.c r_data.c r_draw.c r_main.c r_plane.c r_segs.c r_things.c s_sound.c sb_bar.c sc_man.c sn_sonix.c sounds.c st_start.c sv_save.c
  group doom
    ../doom/src/chocdoom/: i_joystick.c i_main.c i_scale.c i_sound.c i_system.c i_timer.c i_video.c i_videohr.c m_controls.c w_file.c w_file_stdc.c w_main.c w_merge.c w_wad.c v_video.c z_zone.c m_menu.c m_misc.c m_fixed.c m_config.c i_cdmus.c tables.c d_loop.c d_iwad.c doomstat.c d_event.c d_mode.c w_checksum.c sha1.c m_bbox.c m_argv.c m_cheat.c dummy.c p_saveg.c hu_stuff.c hu_lib.c dstrings.c
  group bsp
    ../Src/: stm32f7xx_hal_msp.c
    ../common/STM32F7xx_Driver/BSP/STM32F769I-Discovery/: stm32f769i_discovery_qspi.c stm32f769i_discovery_audio.c stm32f769i_discovery_ts.c stm32f769i_discovery_sdram.c stm32f769i_discovery_sd.c stm32f769i_discovery_lcd.c stm32f769i_discovery.c
    ../common/STM32F7xx_Driver/BSP/Components/adv7533/: adv7533.c
    ../common/STM32F7xx_Driver/BSP/Components/wm8994/: wm8994.c
    ../common/STM32F7xx_Driver/BSP/Components/otm8009a/: otm8009a.c
    ../common/misc/arch/Arm/m7/src/: stm32f7xx_it.c
    ../common/STM32F7xx_Driver/BSP/Components/ft6x06/: ft6x06.c
  group stm32f769-hal-lib
    ./hal-lib/: stm32f769-hal-lib.lib
target stm32f769-hal-lib (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F769NIHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: as above
  output: stm32f769-hal-lib (library)
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F769xx,USE_HAL_DRIVER,USE_STM32F769I_DISCO,DATA_IN_ExtSDRAM,USE_LCD_HDMI,USE_USB_HS
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  scatter file: .\standalone.sct
target application-sram (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F769NIHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: as above
  output: app-sram
  AfterMake: fromelf app-obj\%L --bin --output=app-obj\bin\sram.bin
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F769xx,USE_STM32F769I_DISCO,STM32_SDK,APPLICATION
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  scatter file: .\application-sram.sct
software components: CMSIS:CORE 5.1.2, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDOUT 1.2.0, Compiler:I/O:TTY 1.2.0
